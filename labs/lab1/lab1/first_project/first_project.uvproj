# Keil uVision project first_project.uvproj, settings and files
target QVGA Base Board (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: first_project
  c flags: Optim=1
  asm misc: --diag_suppress 1608,6314
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --first=LPC2400.o(RESET) --diag_suppress 1608,6314
  group Startup Code
    ./src/: LPC2400.s
  group Source Code
    ./src/: IRQ.c main.c LEDCycle.c
