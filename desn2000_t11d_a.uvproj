# Keil uVision project desn2000_t11d_a.uvproj, settings and files
target QVGA Base Board (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: desn2000_t11d_a
  c flags: Optim=1 wLevel=2
  asm misc: --diag_suppress 1608,6314
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --first=LPC2400.o(RESET) --bestdebug --arm_only
  group Source Code
    ./src/: main.c app_logic.c delay.c
    ./src/inputs/: light_sensor.c dial_temp.c doorbell_button.c smart_plug_button.c touch_input.c
    ./src/helper/: timebase.c audio.c blinds.c
    ./src/active_house_operations/: display.c heating_cooling.c morning_routine.c evening_routine.c do_not_disturb.c doorbell_disco.c house_lights.c
  group Startup
    ./src/: LPC2400.s
  group LCD
    ./src/lcd/: font5x7.c lcd_grph.c lcd_hw.c sdram.c
